# Repository Issaimaru/DUB_with_Tono

File README.md:

# DUB_with_Tono
[DriveUnit_Bseries](https://github.com/Issaimaru/MoterDriver_v1)を遠野に刺せるように変換する基板

## 基板外形図<br>
**表**

**裏**

<br>

**実際にDUBと繋げるとこんな感じ**<br>
<br>
~~ちょっと見栄え悪いですね...~~

## 値段<br>
部品を使用していないため，基板代のみ．

## 注意事項
1. この基板を使うと定格電流が野獣と同じくらいになるため，極端に大きい出力が必要な場合には使用しないでください．
1. DUBとはんだ付けをする際は，基板裏面の三角の印が合う向きではんだ付けを行うようにしてください．
1. 逆接すると短絡し大電流が流れます．IN，THRUの矢印の向きに遠野のIN，THRUがあるように接続してください．
1. DUB側で，線で囲まれている部分は電気的に繋げて大丈夫です．はんだ付けする際は取れにくくするために繋げてください．
1. シルクの精度が悪く，裏面のQRコードは読み込めません．

## EAGLE design src/DUB_with_Tono(ver1.0).brd

Parts:
DUB: 10046971-019LF
U$1: YAJU; TOONO
遠野: 5-5530843-4

Connections:
DIR_IN: DUB.P$26 (P26), 遠野.P$21
GND: DUB.P$28 (P28), DUB.P$29 (P29), DUB.P$30 (P30), DUB.P$31 (P31), DUB.P$32 (P32), DUB.P$33 (P33), DUB.P$34 (P34), DUB.P$35 (P35), DUB.P$36 (P36), DUB.P$37 (P37), DUB.P$38 (P38), DUB.P$39 (P39), 遠野.P$14, 遠野.P$15, 遠野.P$16, 遠野.P$17, 遠野.P$18, 遠野.P$23, 遠野.P$24, 遠野.P$25, 遠野.P$26, 遠野.P$27
GND_IN: DUB.P$24 (P24), 遠野.P$19
PWM_IN: DUB.P$25 (P25), 遠野.P$20
SA: DUB.P$1 (P1), DUB.P$2 (P2), DUB.P$3 (P3), DUB.P$4 (P4), DUB.P$5 (P5), DUB.P$45 (P45), DUB.P$46 (P46), DUB.P$47 (P47), DUB.P$48 (P48), DUB.P$49 (P49), DUB.P$50 (P50), 遠野.P$1, 遠野.P$2, 遠野.P$3, 遠野.P$4, 遠野.P$37, 遠野.P$38, 遠野.P$39, 遠野.P$40
SB: DUB.P$6 (P6), DUB.P$7 (P7), DUB.P$8 (P8), DUB.P$9 (P9), DUB.P$10 (P10), DUB.P$11 (P11), DUB.P$40 (P40), DUB.P$41 (P41), DUB.P$42 (P42), DUB.P$43 (P43), DUB.P$44 (P44), 遠野.P$5, 遠野.P$6, 遠野.P$7, 遠野.P$8, 遠野.P$33, 遠野.P$34, 遠野.P$35, 遠野.P$36
VCC: DUB.P$12 (P12), DUB.P$13 (P13), DUB.P$14 (P14), DUB.P$15 (P15), DUB.P$16 (P16), DUB.P$17 (P17), DUB.P$18 (P18), DUB.P$19 (P19), DUB.P$20 (P20), DUB.P$21 (P21), DUB.P$22 (P22), DUB.P$23 (P23), 遠野.P$9, 遠野.P$10, 遠野.P$11, 遠野.P$12, 遠野.P$13, 遠野.P$28, 遠野.P$29, 遠野.P$30, 遠野.P$31, 遠野.P$32
VCC_IN: DUB.P$27 (P27), 遠野.P$22

Notes on the sheet:
e2011220 竹内一晴
5-5530843-4

Board: 2 copper layers, 66.0 x 21.6 mm, 3 parts (0 on the bottom side), 8 nets.

## Commit log

2022-06-27 キャッシュの削除
2022-06-28 ベタの追加
2022-06-28 ビアの追加
2022-06-28 前バージョン
2022-06-29 Eagle移行前_基板配線完成
2022-06-29 Eagle移行前_遠野ライブラリの修正
2022-06-29 デザインの完成
2022-06-29 gerberの追加
2022-06-29 はんだ補助の線の追加
2022-06-29 Update README.md
    基板外形図の追加
2022-06-30 Update README.md
    誤字の訂正
2022-08-06 Update LICENSE
